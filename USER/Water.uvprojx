# Keil uVision project Water.uvprojx, settings and files
target FreeRTOS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Water +hex
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER,DEBUG,OS_CRITICAL_METHOD
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\HARDWARE\ADC;..\HARDWARE\LAN8720;..\HARDWARE\MPU;..\HARDWARE\PCF8574;..\HARDWARE\RTC;..\HARDWARE\SDRAM;..\HARDWARE\MY_TIMER;..\HARDWARE\IIC;..\MALLOC;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_client_demo;..\LWIP\lwip_app\tcp_server_demo;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip_app\web_server_demo;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\api;..\LWIP;..\HARDWARE\KEY;..\SYSTEM\my_malloc;..\HARDWARE\24C02;..\HARDWARE\MY_SPI;..\HARDWARE\softIIcProxy;..\Modbus\ascii;..\Modbus\functions;..\Modbus\include;..\Modbus\port;..\Modbus\rtu;..\Modbus\tcp;..\ApplicationLayer;..\BusinessLogicLayer;..\FunctionMoudleLayer;..\HARDWARE\ADS_1256;..\Modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/my_malloc/: my_malloc.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_adc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_eth.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_spi.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LAN8720/: lan8720.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MY_TIMER/: my_timer.c
    ../HARDWARE/24C02/: 24C02.c
    ../HARDWARE/softIIcProxy/: softIIcProxy.c
    ../HARDWARE/MY_SPI/: my_spi.c
    ../HARDWARE/ADS_1256/: ADS_1256.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Modbus
    ../Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Modbus/ascii/: mbascii.c
    ../Modbus/rtu/: mbcrc.c mbrtu.c
    ../Modbus/tcp/: mbtcp.c
    ../Modbus/: mb.c
  group Port
    ../Modbus/port/: portevent.c portserial.c porttimer.c
  group ApplicationLayer
    ../ApplicationLayer/: lwip_client_app.c RTOS_Task.c
  group BusinessLogicLayer
    ../BusinessLogicLayer/: BLL_Alarm.c BLL_MainFsm.c BLL_Modbus.c Mersm_Debug.c Mersm_Dry.c Mersm_LeakTest.c Mersm_Test.c
  group FunctionMoudleLayer
    ../FunctionMoudleLayer/: FML_Daq.c FML_DelayTime.c FML_ExtProporV.c FML_ExtSignal.c FML_ExtValve.c FML_Grat.c GeneralFunc.c
